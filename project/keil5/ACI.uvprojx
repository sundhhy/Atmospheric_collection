# Keil uVision project ACI.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PplRcd
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL,HSE_VALUE=8000000,_MCU_ENDIAN=1
  c misc: --diag_suppress=1295;--diag_suppress=1;--diag_suppress=177-D
  c include: ..\..\configs;..\..\BSP;E:\sdhLib\inc;..\..\device\dev_LCD\nokia_5110;..\..\..\Atmospheric_collection;..\..\drive;..\..\device;..\..\GUI\Glyph;..\..\GUI\Expression;..\..\Views;..\..\REEC;..\..\model;..\..\GUI\sheet;..\..\usb;..\..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ../../APP/: app_conf.h main.c osObjects.h sdhlibConf.h system.c system.h Cmd_Thread.c sys_cmd.h Modbus_app.c Modbus_app.h channel_accumulated.c channel_accumulated.h
  group config
    ../../configs/: hardwareConfig.c hardwareConfig.h tdd_conf.h lcd_conf.h hmi_conf.h model_conf.h
  group BSP
    ../../BSP/: intrInit.c mySystemClock.c pinmux.c power.c power.h
  group myLib
    E:/sdhLib/src/basis/: marco.c assert.c except.c
    E:/sdhLib/src/arithmetic/: cycQueue.c list.c bit.c crc.c
    E:/sdhLib/src/Communication/: smart_bus.c modbusRTU_cli.c
    E:/sdhLib/src/os/RTX/: rtx_depend.c
    E:/sdhLib/src/mem/: mem.c Ping_PongBuf.c
    E:/sdhLib/inc/arithmetic/: bit.h crc.h
    E:/sdhLib/inc/basis/: assert.h sdhError.h
    E:/sdhLib/inc/Communication/: modbusRTU_cli.h
  group drive
    ../../drive/GPIO/: drive_gpio.c drive_gpio.h
    ../../drive/IIC/: drive_IIC.c
    ../../drive/SPI/: drive_spi.c
    ../../drive/uart/: drive_uart.c drive_uart.h
  group device
    ../../device/: device.c dev_lcd.c dev_cmd.h dev_lcd.h deviceId.h device.h dev_char.c
    ../../device/dev_uart/: dev_uart.c
    ../../device/dev_spi/: dev_spi.c
    ../../device/dev_IIC/: dev_IIC.c
    ../../device/dev_gpio/: device_gpio.c device_gpio.h
    ../../device/dev_LCD/FM12864/: dev_lcd_fm12864.h lcd_hardware_interfaces.h dev_lcd_fm12864.c lcd_hardware_interfaces.c
  group utils
    ../../utils/: FM25.c hw_w25q.c keyboard.c rtc.c rtc_pcf8563.c Storage.c times.c Storage.h PHN_string.c PHN_string.h FM25.h
  group HMI
    ../../HMI/: chnInfoPic.c Component_Button.c focus.c format.c HMI.c HMIFactory.c HMI.h HMIFactory.h Component_Button.h Component_progress_bar.c Component_progress_bar.h Component_curve.h Component_curve.c Component_tips.c Component_tips.h HMI_comm.c HMI_main.c HMI_config.h HMI_config.c focus.h HMI_comm.h HMI_setting.h HMI_setting.c HMI_select_setting.c HMI_select_setting.h Component_option.h Component_option.c HMI_configuring.h HMI_configuring .c configure_strategy.h CST_set_time.c configure_strategy.c CST_set_display.c CST_set_password.c CST_set_atmosphere_pressure.c CST_set_pressure_protect.c CST_set_heater.c CST_set_dust_flow.c CST_set_vapor_pressure .c CST_set_case_temperature.c HMI_query.c HMI_query.h CST_query_atmosphere.c
  group model
    ../../model/: Model.c Model_channel.c ModelFactory.c ModelTime.c Model.h Model_channel.h model_atmosphere.c model_atmosphere.h
  group control
    ../../Control/: Controller.c Controller.h CtlKey.c CtlKey.h CtlTimer.c CtlTimer.h
  group USB
    ../../USB/: Ch376.c Usb.c Ch376INC.h Usb.h Ch376.h
  group fs
    ../../fs/: easy_fs.c easy_fs.h
  group GUI
    ../../GUI/Glyph/: Gh_None.c glyph.c Gh_Pic.c Gh_txt.c Gh_Rectangle.c character_database.c character_database.h
    ../../GUI/Expression/: ExpFactory.c TxtExpr.c Reader.c expression.c NtButton.c NtInput.c GeometricsExpr.c PicExpr.c
    ../../GUI/sheet/: sheet.c sheetMemento.c
  group unit_test
    ../../unit_tests/: test_lcd.c unit_test.c test_lcd.h unit_test.h test_key.c test_key.h
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
