# Keil uVision project ACI.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ACI
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL,HSE_VALUE=8000000,_MCU_ENDIAN=1
  c misc: --diag_suppress=1295;
  c include: E:\sdhLib\inc;..\..\app;..\..\..\Atmospheric_collection;..\..\device;..\..\drive
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ../../app/: main.c
  group device
    ../../device/: device.h device.c dev_lcd.c dev_char.c dev_id.h dev_char.h dev_lcd.h
    ../../device/dev_lcd/FM12864/: dev_lcd_fm12864.c dev_lcd_fm12864.h lcd_hardware_interfaces.c lcd_hardware_interfaces.h
  group GUI
    ../../GUI/glyph/: character_database.h character_database.c
  group configs
    ../../configs/: hardware_conf.h dev_conf.h hardware_conf.c tdd_conf.h lcd_conf.h
  group unit_test
    ../../unit_tests/: unit_test.c unit_test.h test_lcd.c test_lcd.h
  group BSP
    ../../BSP/: intrInit.h mySystemClock.h pinmux.h power.h intrInit.c mySystemClock.c pinmux.c power.c
  group lib
    E:/sdhLib/src/os/RTX/: rtx_depend.c
    E:/sdhLib/src/arithmetic/: bit.c
    E:/sdhLib/src/basis/: marco.c except.c assert.c
    E:/sdhLib/src/mem/: mem.c
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX 4.81.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
